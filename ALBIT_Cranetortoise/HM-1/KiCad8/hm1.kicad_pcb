# Repository kanengomibako/ReverseEngineering

## KiCad design ALBIT_Cranetortoise/HM-1/KiCad8/hm1.kicad_pcb

Parts:
BT1: Battery; my_conn
C1: 220u; CP_Radial_D6.3mm_P2.50mm
C2, C5, C10, C15, C16: 1u; CP_Radial_D5.0mm_P2.50mm
C3: 220p; C_Disc_D3.0mm_W2.0mm_P2.50mm
C4, C21: 100n; C_Rect_L7.0mm_W2.0mm_P5.00mm
C6: 0.22u; my_C_NP_P2.50mm
C7: 0.47u; CP_Radial_D5.0mm_P2.50mm
C8, C13: 47n; C_Rect_L7.0mm_W2.0mm_P5.00mm
C9: 10u; my_C_NP_P2.50mm
C11: 47p; C_Disc_D3.0mm_W2.0mm_P2.50mm
C12: 100p; C_Disc_D3.0mm_W2.0mm_P2.50mm
C14, C19: 470p; C_Disc_D3.0mm_W2.0mm_P2.50mm
C17: 47u; CP_Radial_D5.0mm_P2.50mm
C18: 2200u; CP_Radial_D8.0mm_P5.00mm
C20: 820p; C_Disc_D3.0mm_W2.0mm_P2.50mm
C22: 22n; C_Rect_L7.0mm_W2.0mm_P5.00mm
D1: 1N4002; D_DO-35_SOD27_P10.16mm_Horizontal
D2, D3, D4: ?; D_DO-35_SOD27_P7.62mm_Horizontal
D9: LED; my_conn
IC1: NJM5532DD; DIP-8_W7.62mm
J1: INPUT; Audio_Jack_EX
J2: OUTPUT; Audio_Jack_EX
J3: DC_IN; my_DC_Jack
Q1: 2SC1815-Y; TO-92_Wide
Q2: 2SK105; TO-92_Wide
R1: 3.3M; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R2, R3: 68k; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R4, R5, R19, R25: 100k; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R6, R24: 10k; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R8: 22R; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R10, R21: 22k; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R11: 3.3k; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R13: 27k; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R15: 470k; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R16, R22: 33k; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R17: 330k; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R18: 100R; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R20, R23: 1M; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R27: 1.5k; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R28: 100k; R_Axial_DIN0204_L3.6mm_D1.6mm_P7.62mm_Horizontal
R29, R30, R31: 47k; R_Axial_DIN0204_L3.6mm_D1.6mm_P7.62mm_Horizontal
R32: 100k; C_Disc_D3.0mm_W1.6mm_P2.50mm
R33: 68k; R_Axial_DIN0204_L3.6mm_D1.6mm_P7.62mm_Horizontal
SW1: SW1; PinHeader_2x03_P2.54mm_Vertical
SW2: SW2; PinHeader_2x03_P2.54mm_Vertical
VR1: B100k; PinHeader_1x03_P2.54mm_Vertical
VR2: A20k; PinHeader_1x03_P2.54mm_Vertical

Connections:
BYPASS: C15.1, C16.1, Q2.3 (S), R16.2
GND: C1.2, C6.2, C12.1, C14.1, C17.2, C18.2, C22.1, D1.2 (A), D3.2 (A), D9.1 (K), IC1.4 (V-), J1.S, J2.S, J3.1, Q1.1 (E), R4.1, R16.1, R19.1, R22.1, R25.1, VR2.1
unnamed: BT1.1 (+), J3.3
unnamed: BT1.2 (-), J1.R
unnamed: C2.2, C3.1, R3.1
unnamed: C3.2, R3.2, VR2.3
unnamed: C4.1, R2.1, R5.2
unnamed: C4.2, C5.2, R4.2
unnamed: C7.1, R6.2
unnamed: C8.1, VR2.2
unnamed: C9.1, VR1.3
unnamed: C9.2, R11.1
unnamed: C10.1, IC1.1, R32.2
unnamed: C10.2, R18.1
unnamed: C5.1, C11.2, IC1.7, R6.1, R15.2, R29.2
unnamed: C13.1, R24.2
unnamed: C14.2, J1.T, R24.1
unnamed: C15.2, R21.1
unnamed: C8.2, C19.1, C20.1, C21.1, R28.1
unnamed: C21.2, R31.1
unnamed: C22.2, R30.1, R31.2
unnamed: D1.1 (K), J3.2, R8.1
unnamed: C7.2, D2.2 (A), D3.1 (K)
unnamed: C6.1, D2.1 (K), R5.1
unnamed: D4.2 (A), SW1.5 (B)
unnamed: D4.1 (K), R27.1
unnamed: D9.2 (A), SW1.6 (C)
unnamed: C12.2, IC1.3 (+), R17.2, SW2.2 (B)
unnamed: IC1.2 (-), R32.1, R33.2
unnamed: IC1.5 (+), R20.2, R21.2
unnamed: C11.1, IC1.6 (-), R11.2, R15.1, SW2.4 (A)
unnamed: Q1.3 (B), R1.1, R2.2
unnamed: C2.1, Q1.2 (C), R1.2, R10.1
unnamed: C13.2, Q2.2 (G), R23.2
unnamed: C16.2, R25.2, SW1.1 (A)
unnamed: J2.T, SW1.2 (B)
unnamed: R18.2, R19.2, SW1.3 (C)
unnamed: C19.2, R28.2, SW2.1 (A)
unnamed: C20.2, R30.2, SW2.3 (C)
unnamed: R29.1, SW2.5 (B)
VB: C17.1, R13.2, R17.1, R20.1, R22.2, R23.1, R33.1, VR1.1, VR1.2
VCC: C1.1, C18.1, IC1.8 (V+), Q2.1 (D), R8.2, R10.2, R13.1, R27.2

Notes on the sheet:
Cranetortoise HM-1 蛇鉄
D2, D3: 1N4148 or similar
GAIN
Snake Iron
Traced by kanengomibako Mar. 2024
VOLUME

Board: 2 copper layers, 56.0 x 110.0 mm, 66 parts (2 on the bottom side), 42 nets.

## KiCad design Caline/CP-60/KiCad7/cp60.kicad_pcb

Parts:
C1, C2, C5, C6, C7, C16, C26, C27: 22n; C_0603_1608Metric
C3, C11, C18, C19, C35: 10n; C_0603_1608Metric
C4: 2.2n; C_0603_1608Metric
C8, C15, C34, C38: 47n; C_0603_1608Metric
C9: 560p; C_0603_1608Metric
C10: 1n; C_0603_1608Metric
C12, C13: 270p; C_0603_1608Metric
C14, C25, C33: 100n; C_0603_1608Metric
C17, C20, C21: 2.2u; C_0603_1608Metric
C22, C23, C24: 47p; C_0603_1608Metric
C28, C29: 100u; CP_Radial_D4.0mm_P2.00mm
C30, C31, C32, C36: 10u; C_0603_1608Metric
C37, C39, C40, C41: 1u; C_0603_1608Metric
D2, D4: D; D_MiniMELF
D3: SS14; D_SMA
D5, D6: D; my_D_P5.08mm_Horizontal
DC1: DC_IN; PinHeader_1x02_P2.54mm_Vertical
J1: IN; Jack_6.35mm_Neutrik_NMJ6HCD2_Horizontal
J2: OUT; Jack_6.35mm_Neutrik_NMJ4HCD2_Horizontal
J3: XLR_OUT; PinHeader_1x04_P2.54mm_Vertical
LED1: LED; LED_D5.0mm
Q1, Q2: 2SK246-GR; TO-92_Inline_Wide
Q3, Q4, Q5: 2SC1815; SOT-23
R1, R19, R20, R46, R47: 1M; R_0603_1608Metric
R2, R5, R7, R23, R24, R26, R27, R33, R35, R37, R38, R39, R40, R42, R43, R48, R50, R55, R57: 10k; R_0603_1608Metric
R3, R4: 100k; R_0603_1608Metric
R6, R8, R11, R15, R18, R29, R30, R51: 22k; R_0603_1608Metric
R9, R10: 33k; R_0603_1608Metric
R12, R13: 330k; R_0603_1608Metric
R14: 2.2k; R_0603_1608Metric
R16, R17, R31, R34: 3.3k; R_0603_1608Metric
R21: 6.2k; R_0603_1608Metric
R22: 4.7k; R_0603_1608Metric
R25, R28, R44, R45, R53, R56: 1k; R_0603_1608Metric
R32: 2.2M; R_0603_1608Metric
R36, R41: 100R; R_0603_1608Metric
R49: 51k; R_0603_1608Metric
R52, R58, R59: 510k; R_0603_1608Metric
R54: 9.1k; R_0603_1608Metric
SW1: SW_3PDT; my_sw_3pdt
U1: NJM4558; my_SOIC-8_3.9x4.9mm_Pitch1.27mm
U2, U3: TL074; my_SOIC-14_3.9x8.7mm_Pitch1.27mm
U4: NJM4580; my_SOIC-8_3.9x4.9mm_Pitch1.27mm
VR1, VR2, VR3, VR4, VR5, VR6: B100k; my_pot_5mm

Connections:
GND: C28.2, C29.2, C33.1, C34.1, C35.1, C36.1, C38.1, D4.2 (A), DC1.1, J1.S, J1.SN, J1.TN, J2.S, J2.SN, J3.1, Q5.2 (E), R19.2, R20.2, R24.2, R27.2, R35.2, R43.2, R51.2, R55.2, R57.2, SW1.5 (B), SW1.8 (B), U1.4 (V-), U2.11 (V-), U3.11 (V-), U4.4 (V-)
unnamed: C1.1, R2.2
unnamed: C1.2, J1.T
unnamed: C2.2, C7.2, R3.1
unnamed: C3.2, R6.1, R7.1, R8.2
unnamed: C4.2, R9.1, R10.2
unnamed: C5.1, C6.2, R14.1
unnamed: C6.1, C7.1, R15.1
unnamed: C8.2, R7.2
unnamed: C11.2, R17.1
unnamed: C13.1, R5.2, R13.1, U2.7
unnamed: C14.1, VR3.3
unnamed: C15.1, C16.1, R21.1
unnamed: C17.2, C37.1, R19.1
unnamed: C18.1, VR5.3
unnamed: C18.2, C25.1, R40.2
unnamed: C19.1, C23.1, R25.2, R32.1, R42.1, U3.8
unnamed: C19.2, VR5.1
unnamed: C20.1, R25.1
unnamed: C20.2, C41.1, R20.1
unnamed: C21.1, C40.2
unnamed: C22.1, C25.2, R29.1, U3.7
unnamed: C24.1, C32.1, R39.1, U4.7
unnamed: C26.1, R40.1, VR6.3
unnamed: C26.2, C27.2, R37.2, VR6.2
unnamed: C27.1, R42.2, VR6.1
unnamed: C30.2, R27.1, R28.2
unnamed: C31.2, R35.1, R36.2
unnamed: C32.2, R41.2, R43.1
unnamed: C36.2, R51.1, R52.2, R54.2
unnamed: C37.2, R53.2
unnamed: D2.2 (A), D4.1 (K), R44.2, R45.1
unnamed: D3.2 (A), DC1.2
unnamed: D5.2 (A), Q2.2 (G)
unnamed: C38.2, D5.1 (K), R46.2
unnamed: D6.2 (A), Q1.2 (G)
unnamed: C34.2, D6.1 (K), R47.1
unnamed: J2.T, R28.1
unnamed: J3.2, R41.1, R45.2
unnamed: J3.3, R36.1, R44.1
unnamed: LED1.2 (A), R22.2
unnamed: LED1.1 (K), SW1.4 (A)
unnamed: C41.2, Q1.3 (D), R59.1
unnamed: C40.1, Q1.1 (S), Q2.3 (D)
unnamed: C39.2, Q2.1 (S), R58.1
unnamed: Q3.1 (B), R52.1, R53.1
unnamed: Q3.2 (E), R55.1, R56.2
unnamed: Q4.1 (B), R56.1
unnamed: C39.1, Q4.2 (E), R57.1
unnamed: Q5.1 (B), R49.1
unnamed: Q5.3 (C), R47.2, R48.2
unnamed: R5.1, R6.2, R11.1
unnamed: R16.2, VR2.3
unnamed: R17.2, VR1.3
unnamed: R31.1, VR5.2
unnamed: C35.2, R46.1, R49.2, R50.1, SW1.7 (A)
unnamed: R1.1, R2.1, U1.3 (+)
unnamed: C5.2, C17.1, R3.2, U1.1, U1.2 (-), VR3.1
unnamed: C15.2, R18.1, U1.5 (+)
unnamed: C14.2, U1.6 (-), U1.7
unnamed: C2.1, R4.1, U2.3 (+)
unnamed: C11.1, C12.2, R12.2, U2.2 (-)
unnamed: C12.1, R12.1, U2.1, U2.5 (+)
unnamed: C13.2, R13.2, R16.1, U2.6 (-)
unnamed: C9.2, R8.1, U2.10 (+)
unnamed: C3.1, R9.2, U2.8, U2.9 (-)
unnamed: C10.2, R10.1, U2.12 (+)
unnamed: C4.1, C16.2, R18.2, U2.13 (-), U2.14
unnamed: U3.3 (+), VR4.2
unnamed: R33.2, U3.1, U3.2 (-)
unnamed: C22.2, R29.2, R33.1, U3.6 (-)
unnamed: C23.2, R31.2, R32.2, R37.1, U3.9 (-)
unnamed: C21.2, R23.1, U3.12 (+)
unnamed: C30.1, R30.2, U3.13 (-), U3.14
unnamed: R30.1, R34.1, U4.3 (+)
unnamed: C31.1, R38.2, U4.1, U4.2 (-)
unnamed: C24.2, R38.1, R39.2, U4.6 (-)
unnamed: VR3.2, VR4.3
VCC: C28.1, C33.2, D2.1 (K), D3.1 (K), Q3.3 (C), Q4.3 (C), R22.1, R26.1, R48.1, R50.2, R54.1, U1.8 (V+), U2.4 (V+), U3.4 (V+), U4.8 (V+)
VCOM: C8.1, C9.1, C10.1, C29.1, R1.2, R4.2, R11.2, R14.2, R15.2, R21.2, R23.2, R24.1, R26.2, R34.2, R58.2, R59.2, U3.5 (+), U3.10 (+), U4.5 (+), VR1.1, VR1.2, VR2.1, VR2.2, VR4.1

Notes on the sheet:
MIX
LOW
Traced by kanengomibako Nov. 2023
VOLUME
DRIVE
Caline CP-60 WINE CELLAR
v3.2 2019/06/19
HARMONICS
HIGH

Board: 2 copper layers, 92.0 x 72.0 mm, 126 parts (0 on the bottom side), 80 nets.

## KiCad design Cult/Ray/KiCad7/ray.kicad_pcb

Parts:
C1: 22n; my_C_P19mm
C2: 150p; my_C_Rect1_P5.00mm
C3, C9: 1u; my_C_P19mm
C4: 47n; my_C_Rect1_P5.00mm
C5: 330p; my_C_Rect1_P5.00mm
C6, C11: 10n; my_C_Rect1_P5.00mm
C7, C8: 100u; CP_Axial_L11.0mm_D6.0mm_P18.00mm_Horizontal
C10: 56n; my_C_Rect1_P5.00mm
J1: In; my_SmallPad_0-8mmDrill
J2: Out; my_SmallPad_0-8mmDrill
J3: V+; my_SmallPad_0-8mmDrill
J4, J5, J6: GND; my_SmallPad_0-8mmDrill
J7: LED; my_SmallPad_0-8mmDrill
Q1, Q2: 2N7000; TO-92_Inline_Wide
Q3: 2SC1815-GR; TO-92_Inline_Wide
R1, R3: 2.2M; my_R_P11mm
R2: 620k; my_R_P11mm
R4: 8.2k; my_R_P11mm
R5: 3.3k; my_R_P11mm
R6, R14, R16, R17: 10k; my_R_P11mm
R7, R11: 1k; my_R_P11mm
R8: 49.9k; my_R_P11mm
R9: 6.81k; my_R_P11mm
R10: 56.2k; my_R_P11mm
R12: 18.2k; my_R_P11mm
R13: 47R; my_R_P11mm
R15: 100k; my_R_P11mm
R18: Jumper; R_Axial_DIN0204_L3.6mm_D1.6mm_P7.62mm_Horizontal
U1: OP270GP; DIP-8_W7.62mm_Socket
VR1: 500kA; my_pot
VR2, VR3: 50kC; my_pot
VR4: 50kB; my_pot

Connections:
+4.5V: C4.1, C7.1, R2.1, R3.1, R14.2, R15.1, R16.2
+9V: C8.1, Q3.2 (C), R13.2, R14.1, U1.8 (V+)
GND: C6.1, C7.2, C8.2, J4.1, J5.1, J6.1, R1.1, R16.1, R17.1, U1.4 (V-), VR4.1
unnamed: C1.1, R2.2, R4.1
unnamed: C3.1, R11.1
unnamed: C4.2, R5.1
unnamed: C5.2, R7.1, R8.2, U1.1
unnamed: C6.2, VR2.2
unnamed: C9.1, VR4.3
unnamed: C9.2, R7.2
unnamed: C10.1, C11.2, R12.1
unnamed: C10.2, VR3.2
unnamed: C1.2, J1.1, R1.2
unnamed: J2.1, VR4.2
unnamed: J3.1, J7.1, R18.1
unnamed: C2.1, Q1.2 (G), Q1.3 (D), Q2.1 (S), R5.2, U1.6 (-), VR1.2, VR1.3
unnamed: C2.2, C3.2, Q1.1 (S), Q2.2 (G), Q2.3 (D), R6.1, U1.7
unnamed: C11.1, Q3.3 (B), R15.2
unnamed: Q3.1 (E), R12.2, R17.2
unnamed: R6.2, VR1.1
unnamed: R9.1, VR3.3
unnamed: R10.2, VR3.1
unnamed: R11.2, VR2.3
unnamed: R13.1, R18.2
unnamed: R3.2, R10.1, U1.3 (+), VR2.1
unnamed: C5.1, R8.1, R9.2, U1.2 (-)
unnamed: R4.2, U1.5 (+)

Notes on the sheet:
Treble
CULT Ray
Bass
Traced by kanengomibako May 2023
Drive
Volume

Board: 2 copper layers, 67.9 x 79.0 mm, 44 parts (0 on the bottom side), 27 nets.

## KiCad design Fender/HammertoneOverdrive/KiCad7/hammertone_od.kicad_pcb

Parts:
BT1: Battery; my_conn
C1, C16, C21: 33n; C_0805_2012Metric
C2, C11, C18, C26: 100u; CP_Elec_6.3x5.3
C3, C8, C13, C22, C27: 100n; C_0402_1005Metric
C4: 220p; C_0402_1005Metric
C5: 1u; CP_Elec_4x5.3
C6, C12: 100n; C_1206_3216Metric
C7: 10n; C_0805_2012Metric
C9, C14, C20, C24, C30: 47p; C_0402_1005Metric
C10, C23: 22n; C_0805_2012Metric
C15, C17, C19, C25: 10u; CP_Elec_4x5.3
C28: 10u; C_0805_2012Metric
C29: 1u; C_0402_1005Metric
D1, D2, D3, D4, D6, D7: 1N4148W; D_SOD-123
D5: S1M; D_SMA
FB101, FB102: -
J1: DC_Jack; my_DC_Jack
J1.1, J1.2, J1.3, J1.4, J1.5, J1.6: -; my_TestPoint_1mm
J101: IN
J102: OUT
LED1: Red; LED_D3.0mm
Q1: MMBT4401L; SOT-23
Q2: 2N7002K; SOT-23
R1: 1M; R_0805_2012Metric
R2, R5, R6, R14: 47k; R_0402_1005Metric
R3: 62k; R_0402_1005Metric
R4: 1M; R_0603_1608Metric
R7, R15, R26, R29: 3.3k; R_0402_1005Metric
R8: 50kC; PinHeader_1x03_P2.54mm_Vertical
R9: 220k; R_0603_1608Metric
R10: 330R; R_0402_1005Metric
R11, R12, R13, R18, R19, R20, R22, R33: 10k; R_0402_1005Metric
R16: 33k; R_0402_1005Metric
R17: 500kA; PinHeader_1x03_P2.54mm_Vertical
R21: 100k; R_0402_1005Metric
R23: 22k; R_0402_1005Metric
R24: 1k; R_0402_1005Metric
R25: 10k; my_trim2
R27, R31, R34: 470R; R_0402_1005Metric
R28: 50kB; PinHeader_1x03_P2.54mm_Vertical
R30: 10kA; PinHeader_1x03_P2.54mm_Vertical
R32: 1.2k; R_0402_1005Metric
R35: Empty; my_trim2
R36: 0R; R_0402_1005Metric
SW1: SW
U1: NJM5532; SOIC-8_3.9x4.9mm_P1.27mm
U2, U3: RC4558; SOIC-8_3.9x4.9mm_P1.27mm

Connections:
+5V: C2.1, C3.1, R2.1, R3.1, R4.2, R6.2, R9.2
+9V: C8.1, C13.1, C22.1, C26.1, C27.1, C28.1, C29.1, D5.1 (K), D6.2 (A), J1.2, Q1.3 (C), R2.2, R12.2, R19.2, U1.8 (V+), U2.8 (V+), U3.8 (V+)
GND: C2.2, C3.2, C4.2, C8.2, C11.2, C12.2, C13.2, C16.2, C18.2, C19.2, C21.2, C22.2, C23.2, C26.2, C27.2, C28.2, C29.2, C30.2, D3.1 (K), D4.2 (A), D5.2 (A), J1.2.1, J1.4.1, J101.S, J102.S, Q2.2 (S), R1.2, R3.2, R5.2, R13.1, R20.2, R30.1, R33.2, U1.4 (V-), U2.4 (V-), U3.4 (V-)
unnamed: BT1.1 (+), J1.3
unnamed: BT1.2 (-), J1.1, J1.6.1, J101.R
unnamed: C1.2, C4.1, R1.1, R34.1
unnamed: C6.1, R8.1, R8.2
unnamed: C6.2, C7.1, R10.1
unnamed: C9.1, C10.2, R11.1, U1.1
unnamed: C11.1, R12.1, R13.2, R14.1
unnamed: C12.1, R15.2
unnamed: C15.2, R18.2, R33.1
unnamed: C18.1, R19.1, R20.1, R21.2
unnamed: C19.1, R22.2
unnamed: C20.1, R23.1, R24.2, U2.7
unnamed: C23.1, R27.2
unnamed: C24.1, C25.1, R29.1, U3.7
unnamed: C25.2, R30.3
unnamed: C30.1, J1.1.1, R31.1, SW1.5 (B)
unnamed: C14.2, D1.2 (A), D2.1 (K), R15.1, R16.2, U2.2 (-)
unnamed: C14.1, C15.1, D1.1 (K), D2.2 (A), R17.2, R17.3, U2.1
unnamed: C16.1, C17.2, D3.2 (A), D4.1 (K), R18.1
unnamed: D6.1 (K), D7.1 (K), LED1.2 (A)
unnamed: D7.2 (A), J1.5.1, Q2.1 (G), SW1.6 (C)
unnamed: FB101.1, J101.T
unnamed: FB101.2, SW1.2 (B)
unnamed: FB102.1, SW1.3 (C), SW1.4 (A)
unnamed: FB102.2, J102.T
unnamed: J1.3.1, R34.2, SW1.1 (A)
unnamed: LED1.1 (K), R32.2
unnamed: C1.1, Q1.1 (B), R4.1
unnamed: C5.2, Q1.2 (E), R5.1
unnamed: Q2.3 (D), R35.3, R36.1
unnamed: R7.2, R8.3
unnamed: R16.1, R17.1
unnamed: R24.1, R25.1, R25.2
unnamed: R27.1, R28.2
unnamed: R30.2, R31.2
unnamed: R32.1, R35.1, R35.2, R36.2
unnamed: C5.1, R6.1, U1.3 (+)
unnamed: C9.2, R7.1, R11.2, U1.2 (-)
unnamed: C7.2, R9.1, U1.5 (+)
unnamed: R10.2, U1.6 (-), U1.7
unnamed: C10.1, R14.2, U2.3 (+)
unnamed: C17.1, R21.1, U2.5 (+)
unnamed: C20.2, R22.1, R23.2, U2.6 (-)
unnamed: C21.1, R25.3, U3.3 (+)
unnamed: R26.2, U3.1, U3.2 (-)
unnamed: R26.1, R28.1, U3.5 (+)
unnamed: C24.2, R28.3, R29.2, U3.6 (-)

Notes on the sheet:
PRE-MID BOOST
Fender Hammertone Overdrive
TONE
Traced by kanengomibako July 2023
LEVEL
GAIN

Board: 2 copper layers, 56.0 x 80.0 mm, 87 parts (9 on the bottom side), 46 nets.
